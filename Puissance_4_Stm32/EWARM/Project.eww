<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Puissance_4_Stm32.ewp</path>
  </project>
  <batchBuild />
</workspace>
